## build/nrf_ble_mobile/Kconfig/boards/Kconfig.nrf52840dk
```kconfig
# Load board Kconfig descriptions.
osource "C:/ncs/v3.0.1/zephyr/boards/nordic/nrf52840dk/Kconfig.nrf52840dk"
```
